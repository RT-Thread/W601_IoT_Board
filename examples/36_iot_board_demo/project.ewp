# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; WM_W600; __inline=inline; __inline__=inline
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\tinycrypt-v1.0.0\include; ..\..\drivers; packages\FlexibleButton; ..\..\rt-thread\components\libc\compilers\common; ..\..\libraries\WM_Libraries\Platform\Boot\gcc; packages\aht10-v2.0.0; ports\fal; packages\pahomqtt-v1.0.0\MQTTClient-RT; ..\..\libraries\WM_Libraries\Platform\Common\crypto\symmetric; packages\fal-v0.3.0\inc; packages\ap3216c-v2.0.0; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\WM_Libraries\Include\WiFi; ..\..\rt-thread\components\dfs\filesystems\elmfat; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\libraries\WM_Libraries\Platform\Common\crypto\math; packages\infrared-v0.1.1\inc; modules\event; ..\..\rt-thread\components\drivers\include; ports\easyflash; packages\pahomqtt-v1.0.0\MQTTPacket\src; ..\..\libraries\WM_Libraries\Platform\Common\Params; ..\..\rt-thread\include; ports\cloudsdk; ..\..\libraries\WM_Libraries\Include\Platform; ..\..\rt-thread\components\drivers\sensors; .; modules\iotb_workqeue; packages\webclient-v2.1.0\inc; modules\infrared; packages\EasyFlash-v3.3.0\inc; packages\netutils-v1.1.0\ntp; packages\qrcode-v0.1.0\inc; ..\..\rt-thread\components\utilities\ulog; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; ..\..\rt-thread\components\net\sal_socket\include; packages\ota_downloader-v1.0.0; ..\..\libraries\WM_Libraries; modules\key; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; ..\..\libraries\WM_Libraries\Platform\Inc; ..\..\rt-thread\components\dfs\include; ..\..\rt-thread\components\net\sal_socket\impl; applications; packages\cJSON-v1.0.2; ..\..\libraries\WM_Libraries\Include; ..\..\rt-thread\libcpu\arm\cortex-m3; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\drivers\spi; modules\lcd; ..\..\rt-thread\components\drivers\wlan; ..\..\libraries\WM_Libraries\Include\Driver; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\libraries\WM_Libraries\Platform\Common\crypto\digest; ..\..\libraries\WM_Libraries\Platform\Drivers\spi; modules\sensors; ..\..\rt-thread\components\utilities\ymodem; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; ..\..\rt-thread\components\net\lwip-2.0.2\src; ..\..\rt-thread\components\net\netdev\include; ..\..\rt-thread\components\dfs\filesystems\devfs; ..\..\rt-thread\libcpu\arm\common; modules\ymodem; ..\..\libraries\smartconfig\inc; ..\..\libraries\cloudsdk\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; ..\..\libraries\WM_Libraries\Include\OS; ports\wifi; ..\..\libraries\WM_Libraries\Platform\Common\crypto; ..\..\rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\cloudsdk\libs\libcloudsdk_2.0.0_armcm3_iar.a; ..\..\libraries\cloudsdk\libs\librt_ota_noalgo_0.2.3_armcm3_iar.a; ..\..\libraries\smartconfig\libs\libsmartconfig_iar.a; ..\..\libraries\WM_Libraries\Lib\Wlan\libwlan_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group iotb_event
    modules/event/: iotb_event.c
  group iotb_infrared
    modules/infrared/: app_infrared.c
  group iotb_job
    modules/iotb_workqeue/: iotb_workqeue.c
  group iotb_key
    modules/key/: iotb_key_process.c
  group iotb_lcd
    modules/lcd/: iotb_lcd_process.c
  group iotb_sensor
    modules/sensors/: iotb_sensor.c
  group iotb_ymodem
    modules/ymodem/: ymodem_update.c
  group aht10
    packages/aht10-v2.0.0/: aht10.c sensor_asair_aht10.c
  group ap3216c
    packages/ap3216c-v2.0.0/: ap3216c.c sensor_lsc_ap3216c.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v3.3.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.3.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_port.c fal_flash_sfud_port.c
  group flex_button
    packages/FlexibleButton/: flexible_button.c flexible_button_demo.c
  group Infrared_frame
    packages/infrared-v0.1.1/src/: infrared.c nec_decoder.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group ota_downloader
    packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group paho-mqtt
    packages/pahomqtt-v1.0.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.0.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group qrcode
    packages/qrcode-v0.1.0/src/: qrcode.c
    packages/qrcode-v0.1.0/samples/: qrcode_sample.c
  group TinyCrypt
    packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group WebClient
    packages/webclient-v2.1.0/src/: webclient.c webclient_file.c
  group cloudlib
    ports/cloudsdk/: rt_cld_port.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group Sensors
    ../../rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../rt-thread/components/utilities/ulog/: ulog.c
    ../../rt-thread/components/utilities/ulog/backend/: console_be.c
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
  group smartconfig
    ../../libraries/smartconfig/: smartconfig_demo.c
  group Libraries
    ../../libraries/WM_Libraries/Platform/Drivers/cpu/: wm_cpu.c
    ../../libraries/WM_Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    ../../libraries/WM_Libraries/Platform/Drivers/io/: wm_io.c
    ../../libraries/WM_Libraries/Platform/Drivers/irq/: wm_irq.c
    ../../libraries/WM_Libraries/Platform/Drivers/efuse/: wm_efuse.c
    ../../libraries/WM_Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    ../../libraries/WM_Libraries/Platform/Drivers/spi/: wm_hostspi.c
    ../../libraries/WM_Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    ../../libraries/WM_Libraries/Platform/Drivers/dma/: wm_dma.c
    ../../libraries/WM_Libraries/Platform/Drivers/timer/: wm_timer.c
    ../../libraries/WM_Libraries/Platform/Drivers/watchdog/: wm_watchdog.c
    ../../libraries/WM_Libraries/Platform/Drivers/i2c/: wm_i2c.c
    ../../libraries/WM_Libraries/Platform/Drivers/pwm/: wm_pwm.c
    ../../libraries/WM_Libraries/Platform/Drivers/adc/: wm_adc.c
    ../../libraries/WM_Libraries/Platform/Drivers/pmu/: wm_pmu.c
    ../../libraries/WM_Libraries/Platform/Drivers/rtc/: wm_rtc.c
    ../../libraries/WM_Libraries/Platform/Common/Params/: wm_param.c
    ../../libraries/WM_Libraries/Platform/Common/fwup/: wm_fwup.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    ../../libraries/WM_Libraries/rtthread/: rtthread_patch.c
    ../../libraries/WM_Libraries/rtthread/utils/: utils.c
    ../../libraries/WM_Libraries/rtthread/startup/iar/: startup_venus.S
    ../../libraries/WM_Libraries/Platform/Boot/iar/: misc.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c drv_hw_timer.c drv_soft_i2c.c drv_spi.c drv_spiflash.c drv_lcd.c drv_pwm.c drv_spi_tfcard.c drv_infrared.c
