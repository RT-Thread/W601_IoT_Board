# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; SET_TRUSTED_CERT_IN_SAMPLES; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; WM_W600; __inline=inline; __inline__=inline
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\rt-thread\components\libc\compilers\common; ..\..\rt-thread\components\net\sal_socket\include; ports\fal; ..\..\rt-thread\components\dfs\filesystems\devfs; ..\..\rt-thread\components\finsh; packages\fal-v0.3.0\inc; ..\..\libraries\WM_Libraries\Platform\Boot\gcc; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\WM_Libraries\Include\WiFi; packages\mbedtls-v2.7.10\ports\inc; ..\..\rt-thread\components\net\lwip_dhcpd; packages\azure-iot-sdk-v1.2.9\azure\deps\parson; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\rt-thread\components\drivers\include; ..\..\libraries\WM_Libraries\Platform\Common\crypto\symmetric; ports\easyflash; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\inc; ..\..\libraries\WM_Libraries\Platform\Common\Params; ..\..\rt-thread\include; packages\azure-iot-sdk-v1.2.9\azure\c-utility\inc; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\lwip; packages\azure-iot-sdk-v1.2.9\azure\iothub_client\inc; .; ..\..\libraries\WM_Libraries\Include\Driver; ..\..\libraries\WM_Libraries\Include\Platform; packages\EasyFlash-v3.3.0\inc; packages\netutils-v1.1.0\ntp; packages\azure-iot-sdk-v1.2.9\azure\iothub_client\src; packages\azure-iot-sdk-v1.2.9\azure\c-utility\src; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; packages\azure-iot-sdk-v1.2.9\azure\c-utility\inc\azure_c_shared_utility; ..\..\rt-thread\components\net\sal_socket\include\socket; ..\..\rt-thread\components\net\lwip-2.0.2\src; packages\azure-iot-sdk-v1.2.9\azure\umqtt\src; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\libraries\WM_Libraries\Platform\Common\crypto\math; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; ..\..\libraries\WM_Libraries\Platform\Inc; ..\..\rt-thread\components\dfs\include; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal; applications; ..\..\libraries\smartconfig\inc; packages\azure-iot-sdk-v1.2.9\azure\serializer\inc; ..\..\libraries\WM_Libraries\Include; ..\..\rt-thread\libcpu\arm\cortex-m3; ports\wifi; ..\..\rt-thread\components\drivers\spi; ..\..\rt-thread\components\drivers\wlan; packages\azure-iot-sdk-v1.2.9\azure\c-utility\adapters; packages\azure-iot-sdk-v1.2.9\azure-port\pal\inc; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\rt-thread\components\net\sal_socket\impl; ..\..\libraries\WM_Libraries\Platform\Common\crypto\digest; ..\..\libraries\WM_Libraries\Platform\Drivers\spi; ..\..\libraries\WM_Libraries; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; packages\azure-iot-sdk-v1.2.9\azure\serializer\src; ..\..\rt-thread\components\net\netdev\include; packages\azure-iot-sdk-v1.2.9\azure\umqtt\inc; packages\mbedtls-v2.7.10\mbedtls\include; packages\azure-iot-sdk-v1.2.9\azure\umqtt\inc\azure_umqtt_c; ..\..\rt-thread\libcpu\arm\common; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; ..\..\libraries\WM_Libraries\Include\OS; packages\azure-iot-sdk-v1.2.9\azure; ..\..\libraries\WM_Libraries\Platform\Common\crypto; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\generic
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\smartconfig\libs\libsmartconfig_iar.a; ..\..\libraries\WM_Libraries\Lib\Wlan\libwlan_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group azure
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/src/: xlogging.c singlylinkedlist.c buffer.c consolelogger.c constbuffer.c constmap.c doublylinkedlist.c gballoc.c gb_stdio.c gb_time.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c string_tokenizer.c urlencode.c usha.c vector.c xio.c strings.c
    packages/azure-iot-sdk-v1.2.9/azure-port/lib/: c_utility_crt_abstractions.c c_utility_sha1.c c_utility_base64.c azure_certs.c
    packages/azure-iot-sdk-v1.2.9/azure/iothub_client/src/: iothub_client_ll.c iothub_device_client_ll.c iothub_client_core_ll.c iothub_client_authorization.c iothub_message.c iothub_client_diagnostic.c iothub_client_ll_uploadtoblob.c blob.c iothub.c iothubtransportmqtt.c iothubtransport_mqtt_common.c iothub_client_retry_control.c iothubtransporthttp.c
    packages/azure-iot-sdk-v1.2.9/azure/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
    packages/azure-iot-sdk-v1.2.9/azure/deps/parson/: parson.c
    packages/azure-iot-sdk-v1.2.9/azure/serializer/src/: codefirst.c agenttypesystem.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c schemaserializer.c
    packages/azure-iot-sdk-v1.2.9/azure-port/rt-thread/: lock.c threadapi.c tickcounter.c
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/pal/: socket_async.c dns_async.c
    packages/azure-iot-sdk-v1.2.9/azure-port/pal/src/: agenttime.c azure_platform.c tlsio_mbedtls.c socketio_berkeley.c
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/adapters/: httpapi_compact.c
    packages/azure-iot-sdk-v1.2.9/samples/: iothub_ll_telemetry_sample.c iothub_ll_c2d_sample.c
  group EasyFlash
    packages/EasyFlash-v3.3.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.3.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_port.c fal_flash_sfud_port.c
  group mbedtls
    packages/mbedtls-v2.7.10/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.7.10/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../rt-thread/components/net/lwip_dhcpd/: dhcp_server_raw.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c proto_mbedtls.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group smartconfig
    ../../libraries/smartconfig/: smartconfig_demo.c
  group Libraries
    ../../libraries/WM_Libraries/Platform/Drivers/cpu/: wm_cpu.c
    ../../libraries/WM_Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    ../../libraries/WM_Libraries/Platform/Drivers/io/: wm_io.c
    ../../libraries/WM_Libraries/Platform/Drivers/irq/: wm_irq.c
    ../../libraries/WM_Libraries/Platform/Drivers/efuse/: wm_efuse.c
    ../../libraries/WM_Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    ../../libraries/WM_Libraries/Platform/Drivers/spi/: wm_hostspi.c
    ../../libraries/WM_Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    ../../libraries/WM_Libraries/Platform/Drivers/dma/: wm_dma.c
    ../../libraries/WM_Libraries/Platform/Drivers/timer/: wm_timer.c
    ../../libraries/WM_Libraries/Platform/Drivers/watchdog/: wm_watchdog.c
    ../../libraries/WM_Libraries/Platform/Drivers/i2c/: wm_i2c.c
    ../../libraries/WM_Libraries/Platform/Drivers/pwm/: wm_pwm.c
    ../../libraries/WM_Libraries/Platform/Drivers/adc/: wm_adc.c
    ../../libraries/WM_Libraries/Platform/Drivers/pmu/: wm_pmu.c
    ../../libraries/WM_Libraries/Platform/Drivers/rtc/: wm_rtc.c
    ../../libraries/WM_Libraries/Platform/Common/Params/: wm_param.c
    ../../libraries/WM_Libraries/Platform/Common/fwup/: wm_fwup.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    ../../libraries/WM_Libraries/rtthread/: rtthread_patch.c
    ../../libraries/WM_Libraries/rtthread/utils/: utils.c
    ../../libraries/WM_Libraries/rtthread/startup/iar/: startup_venus.S
    ../../libraries/WM_Libraries/Platform/Boot/iar/: misc.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c drv_spi.c drv_spiflash.c
